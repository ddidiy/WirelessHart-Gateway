# IAR project hart7.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F1611 MSP430F1611
  General.GStackSize2: 1000
  General.GHeapSize2: 0
  ICC430.CCDefines: WIRELESS_HART_DEVICE
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F1611.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: main.c
  group hart7_sources/appl_layer/binarization
    ../src/ApplicationLayer/Binarization/: CommonPracticeCommands.h DataLinkLayerCommands.h NetworkLayerCommands.h PhysicalLayerCommands.h UniversalCommands.h
  group hart7_sources/appl_layer/binarization/common practice cmds
    ../src/ApplicationLayer/Binarization/CommonPracticeCommands/: C033_ReadDeviceVariables.c C033_ReadDeviceVariables.h C034_WritePrimaryVariableDampingValue.c C034_WritePrimaryVariableDampingValue.h C035_WritePrimaryVariableRangeValues.c C035_WritePrimaryVariableRangeValues.h C036_SetPrimaryVariableUpperRangeValue.c C036_SetPrimaryVariableUpperRangeValue.h C037_SetPrimaryVariableLowerRangeValue.c C037_SetPrimaryVariableLowerRangeValue.h C040_EnterExitFixedCurrentMode.c C040_EnterExitFixedCurrentMode.h C041_PerformSelfTest.c C041_PerformSelfTest.h C042_PerformDeviceReset.c C042_PerformDeviceReset.h C043_SetPrimaryVariableZero.c C043_SetPrimaryVariableZero.h C044_WritePrimaryVariableUnits.c C044_WritePrimaryVariableUnits.h C045_TrimLoopCurrentZero.c C045_TrimLoopCurrentZero.h C046_TrimLoopCurrentGain.c C046_TrimLoopCurrentGain.h C047_WritePrimaryVariableTransferFunction.c C047_WritePrimaryVariableTransferFunction.h C049_WritePrimaryVariableTransducerSerialNumber.c C049_WritePrimaryVariableTransducerSerialNumber.h C050_ReadDynamicVariableAssignments.c C050_ReadDynamicVariableAssignments.h C051_WriteDynamicVariableAssignments.c C051_WriteDynamicVariableAssignments.h C052_SetDeviceVariableZero.c C052_SetDeviceVariableZero.h C053_WriteDeviceVariableUnits.c C053_WriteDeviceVariableUnits.h C054_ReadDeviceVariableInformation.c C054_ReadDeviceVariableInformation.h C055_WriteDeviceVariableDampingValue.c C055_WriteDeviceVariableDampingValue.h C056_WriteDeviceVariableTransducerSerialNo.c C056_WriteDeviceVariableTransducerSerialNo.h C059_WriteNumberOfResponsePreambles.c C059_WriteNumberOfResponsePreambles.h C060_ReadAnalogChannelAndPercentOfRange.c C060_ReadAnalogChannelAndPercentOfRange.h C062_ReadAnalogChannels.c C062_ReadAnalogChannels.h C063_ReadAnalogChannelInformation.c C063_ReadAnalogChannelInformation.h
  group hart7_sources/appl_layer/binarization/data link layer commands
    ../src/ApplicationLayer/Binarization/DataLinkLayerCommands/: C773_WriteNetworkId.c C773_WriteNetworkId.h C774_ReadNetworkId.c C774_ReadNetworkId.h C781_ReadDeviceNicknameAddress.c C781_ReadDeviceNicknameAddress.h C786_ReadNeighborPropertyFlag.c C786_ReadNeighborPropertyFlag.h C788_AlarmPathDown.c C788_AlarmPathDown.h C810_ReadJoinPriority.c C810_ReadJoinPriority.h C811_WriteJoinPriority.c C811_WriteJoinPriority.h C812_ReadPacketReceivePriority.c C812_ReadPacketReceivePriority.h C813_WritePacketReceivePriority.c C813_WritePacketReceivePriority.h C819_ReadBackOffExponent.c C819_ReadBackOffExponent.h C820_WriteBackOffExponent.c C820_WriteBackOffExponent.h
  group hart7_sources/appl_layer/binarization/network layer commands
    ../src/ApplicationLayer/Binarization/NetworkLayerCommands/: C768_WriteJoinKey.c C768_WriteJoinKey.h C769_ReadJoinStatus.c C769_ReadJoinStatus.h
  group hart7_sources/appl_layer/binarization/physical layer commands
    ../src/ApplicationLayer/Binarization/PhysicalLayerCommands/: C797_WriteRadioPower.c C797_WriteRadioPower.h C798_ReadRadioPower.c C798_ReadRadioPower.h C804_ReadRadioCCAMode.c C804_ReadRadioCCAMode.h C805_WriteRadioCCAMode.c C805_WriteRadioCCAMode.h
  group hart7_sources/appl_layer/binarization/universal cmds
    ../src/ApplicationLayer/Binarization/UniversalCommands/: C000_ReadUniqueIdentifier.c C000_ReadUniqueIdentifier.h C001_ReadPrimaryVariable.c C001_ReadPrimaryVariable.h C002_ReadLoopCurrentAndPercentOfRange.c C002_ReadLoopCurrentAndPercentOfRange.h C003_ReadDynamicVariablesAndLoopCurrent.c C003_ReadDynamicVariablesAndLoopCurrent.h C006_WritePollingAddress.c C006_WritePollingAddress.h C007_ReadLoopConfiguration.c C007_ReadLoopConfiguration.h C008_ReadDynamicVariableClassifications.c C008_ReadDynamicVariableClassifications.h C009_ReadDeviceVariablesWithStatus.c C009_ReadDeviceVariablesWithStatus.h C011_ReadUniqueIdentifierAssociatedWithTag.c C011_ReadUniqueIdentifierAssociatedWithTag.h C012_ReadMessage.c C012_ReadMessage.h C013_ReadTagDescriptorDate.c C013_ReadTagDescriptorDate.h C014_ReadPrimaryVariableTransducerInformation.c C014_ReadPrimaryVariableTransducerInformation.h C015_ReadDeviceInformation.c C015_ReadDeviceInformation.h C016_ReadFinalAssemblyNumber.c C016_ReadFinalAssemblyNumber.h C017_WriteMessage.c C017_WriteMessage.h C018_WriteTagDescriptorDate.c C018_WriteTagDescriptorDate.h C019_WriteFinalAssemblyNumber.c C019_WriteFinalAssemblyNumber.h C020_ReadLongTag.c C020_ReadLongTag.h C021_ReadUniqueIdentifierAssociatedWithLongTag.c C021_ReadUniqueIdentifierAssociatedWithLongTag.h C022_WriteLongTag.c C022_WriteLongTag.h C023_ResetConfigurationChangedFlag.c C023_ResetConfigurationChangedFlag.h C048_ReadAdditionalDeviceStatus.c C048_ReadAdditionalDeviceStatus.h
  group hart7_sources/appl_layer/model
    ../src/ApplicationLayer/Model/: CommonPracticeCommands.h CommonResponseCode.h CommonTables.h DataLinkLayerCommands.h GatewayCommands.h NetworkLayerCommands.h PhysicalLayerCommands.h UniversalCommands.h WirelessNetworkManagerCommands.h
  group hart7_sources/util
    ../src/util/: Binarization.h
    ../src/: int_types.h
